# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, ARM_MATH_CM4, __FPU_PRESENT = 1, __FPU_USED, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: ..\User;..\Lib\CMSIS\Include;..\Lib\CMSIS\Device\ST\STM32F4xx\Include;..\Lib\STM32F4xx_StdPeriph_Driver\inc;..\User\ucCos_App;..\User\uC-CPU;..\User\uC-LIB;..\User\uCOS-II;..\User\uCOS-VIEW;..\User\GLCD;..\User\TouchPanel;..\User\uCGUI;..\User\uCGUI\Config;..\User\uCGUI\inc;..\uCGUI_LIB\USER\uCGUI\AntiAlias;..\uCGUI_LIB\USER\uCGUI\Config;..\uCGUI_LIB\USER\uCGUI\ConvertColor;..\uCGUI_LIB\USER\uCGUI\ConvertMono;..\uCGUI_LIB\USER\uCGUI\Core;..\uCGUI_LIB\USER\uCGUI\Font;..\uCGUI_LIB\USER\uCGUI\GUIDemo;..\uCGUI_LIB\USER\uCGUI\GUIDemo2;..\uCGUI_LIB\USER\uCGUI\JPEG;..\uCGUI_LIB\USER\uCGUI\JPEG\Image;..\uCGUI_LIB\USER\uCGUI\MemDev;..\uCGUI_LIB\USER\uCGUI\MultiLayer;..\uCGUI_LIB\USER\uCGUI\Widget;..\uCGUI_LIB\USER\uCGUI\WM;..\SYSTEM\sys;..\SYSTEM\delay;..\lcd\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
    ../User/ucCos_App/: uctsk_Task.c uctsk_OSView.c app_cfg.h includes.h
  group TouchPanel
    ../User/TouchPanel/: TouchPanel.c
  group Startup
    ../Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group StdPeriph_Driver
    ../Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uC-OS-II/Port
    ../User/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group uC-OS-II/Source
    ../User/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Config
    ../User/ucCos_App/: OS_AppHooks.c os_cfg.h
  group uC-OS-II/CPU
    ../User/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm cpu.h
    ../User/uC-CPU/: cpu_def.h
  group uC-OS-II/LIB/Source
    ../User/uC-LIB/: lib_mem.c lib_str.c lib_def.h lib_mem.h lib_str.h
  group uC-OS-II/VIEW/Source
    ../User/uCOS-VIEW/Source/: os_view.c os_view.h
  group uC-OS-II/VIEW/Port
    ../User/uCOS-VIEW/Ports/ARM-Cortex-M3/Realview/: os_viewc.c os_viewc.h
  group uCOS-Ⅱ/GUI_X
    ../User/uCGUI/: GUI_X_uCOS.c GUI_X_Touch.c
  group uCGUI/GLCD
    ../User/GLCD/: AsciiLib.c GLCD.c GLCD_UCGUI.c
  group uCGUI/Config
    ../User/uCGUI/Config/: GUIConf.h GUITouchConf.h LCDConf.h
  group uC-OS-II/LIB/Port
    ../User/uC-LIB/Ports/RealView/: lib_mem_a.asm
  group uCGUI/Demo
    ../User/uCGUI/uCGUIDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap4bpp.c GUIDEMO_Bitmap.c GUIDEMO_Circle.c GUIDEMO_ColorBar.c GUIDEMO_ColorList.c GUIDEMO_Cursor.c GUIDEMO_Dialog.c GUIDEMO_Font.c GUIDEMO_FrameWin.c GUIDEMO_Graph.c GUIDEMO_HardwareInfo.c GUIDEMO_Intro.c GUIDEMO_LUT.c GUIDEMO_MemDevB.c GUIDEMO_Messagebox.c GUIDEMO_Navi.c GUIDEMO_Polygon.c GUIDEMO_ProgBar.c GUIDEMO_Speed.c GUIDEMO_Touch.c GUIDEMO_WM.c MainTask.c MicriumLogo.c MicriumLogoWRed.c
  group uCGUI/Lib
    ../uCGUI_LIB/: uCGUI.lib
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group lcd
    ../lcd/src/: 24cxx.c ht1621.c key.c myiic.c ch452.c
  group DSP_lib
    ../Lib/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
